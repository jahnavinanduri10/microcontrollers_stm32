/*
 * stm32f407xx_gpio_driver.c
 */

#include "stm32f407xx_gpio_driver.h"



/************************************************************
 * @fn			- GPIO PeriClockcontrol
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */
void GPIO_PeriClockControl(GPIO_RegDef_t *pGPIOx, uint8_t EnorDi)
{
	if(EnorDi == ENABLE)
	{
		if(pGPIOx == GPIOA)
				{
					GPIOA_PCLK_EN();
				}
				else if(pGPIOx == GPIOB)
				{
					GPIOB_PCLK_EN();
				}
				else if(pGPIOx == GPIOC)
				{
					GPIOC_PCLK_EN();
				}
				else if(pGPIOx == GPIOD)
				{
					GPIOD_PCLK_EN();
				}
				else if(pGPIOx == GPIOE)
				{
					GPIOE_PCLK_EN();
				}
				else if(pGPIOx == GPIOF)
				{
					GPIOF_PCLK_EN();
				}
				else if(pGPIOx == GPIOG)
				{
					GPIOG_PCLK_EN();
				}
				else if(pGPIOx == GPIOH)
				{
					GPIOH_PCLK_EN();
				}
				else if(pGPIOx == GPIOI)
				{
					GPIOI_PCLK_EN();
				}
	}
	else
	{
		if(pGPIOx == GPIOA)
		{
			GPIOA_PCLK_DI();
		}
		else if(pGPIOx == GPIOB)
		{
			GPIOB_PCLK_DI();
		}
		else if(pGPIOx == GPIOC)
		{
			GPIOC_PCLK_DI();
		}
		else if(pGPIOx == GPIOD)
		{
			GPIOD_PCLK_DI();
		}
		else if(pGPIOx == GPIOE)
		{
			GPIOE_PCLK_DI();
		}
		else if(pGPIOx == GPIOF)
		{
			GPIOF_PCLK_DI();
		}
		else if(pGPIOx == GPIOG)
		{
			GPIOG_PCLK_DI();
		}
		else if(pGPIOx == GPIOH)
		{
			GPIOH_PCLK_DI();
		}
		else if(pGPIOx == GPIOI)
		{
			GPIOI_PCLK_DI();
		}
	}

}

/************************************************************
 * @fn			- GPIO_Init
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */

void GPIO_Init(GPIO_Handle_t *pGPIOHandle)
{
	uint32_t temp=0; //temp. register

	//enable the peripheral clock
	GPIO_PeriClockControl(pGPIOHandle->pGPIOx, ENABLE);

	//1.	configure the mode of gpio pin

	if(pGPIOHandle->GPIO_PinConfig.GPIO_PinMode <= GPIO_MODE_ANALOG)
	{
		//the non interrupt mode
		temp = (pGPIOHandle->GPIO_PinConfig.GPIO_PinMode << (2 * pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber));
		pGPIOHandle->pGPIOx->MODER &= ~(0x3 << (2 * pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber));//clearing
		pGPIOHandle->pGPIOx->MODER |= temp; //setting

	}
	else
	{
		//(interrupt mode)
		if(pGPIOHandle->GPIO_PinConfig.GPIO_PinMode == GPIO_MODE_IT_FT)
		{
			//1.config the FTSR
			EXTI->FTSR |= (1 << pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber);
			//Clear the corresponding RTSR bit
			EXTI->RTSR &= ~(1 << pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber);
		}
		else if (pGPIOHandle->GPIO_PinConfig.GPIO_PinMode == GPIO_MODE_IT_RT)
		{
			//2.config the RTSR
			EXTI->RTSR |= (1 << pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber);
			//Clear the corresponding FTSR bit
			EXTI->FTSR &= ~(1 << pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber);
		}
		else if (pGPIOHandle->GPIO_PinConfig.GPIO_PinMode == GPIO_MODE_IT_RFT)
		{
			//3.config the FTSR and RTSR
			EXTI->FTSR |= (1 << pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber);

			EXTI->RTSR |= (1 << pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber);
		}

		//2. configure the GPIO port selection in SYSCFG_EXTICR
		uint8_t temp1 =  pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber / 4;
		uint8_t temp2 =  pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber % 4;
		uint8_t portcode = GPIO_BASEADDR_TO_CODE(pGPIOHandle->pGPIOx);
		SYSCFG_PCLK_EN();
		SYSCFG->EXTICR[temp1] &= ~(0xF << (temp2 * 4));  // clear only target bits
		SYSCFG->EXTICR[temp1] |=  (portcode << (temp2 * 4));  // set new value
		//3. enable the exti interrupt delivery using IMR
		EXTI->IMR &= ~(1 << pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber);
		EXTI->IMR |=  1 << pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber;

	}

	temp = 0;
	//2.	configure the speed
	temp = (pGPIOHandle->GPIO_PinConfig.GPIO_PinSpeed << (2 * pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber));
	pGPIOHandle->pGPIOx->OSPEEDR &= ~(0x3 << (2 * pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber)); //clearing
	pGPIOHandle->pGPIOx->OSPEEDR |= temp;

	temp = 0;

	//3.	configure the pupd settings
	temp = (pGPIOHandle->GPIO_PinConfig.GPIO_PinPuPdControl << (2 * pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber));
	pGPIOHandle->pGPIOx->PUPDR &= ~(0x3 << (2 * pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber)); //clearing
	pGPIOHandle->pGPIOx->PUPDR |= temp;

	temp = 0;

	//4.	configure the optype
	temp = (pGPIOHandle->GPIO_PinConfig.GPIO_PinOPType << pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber);
	pGPIOHandle->pGPIOx->OTYPER &= ~( 0x1 << pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber); //clearing
	pGPIOHandle->pGPIOx->OTYPER |= temp;

	temp = 0;

	//5.	configure the alt functionality
	if(pGPIOHandle->GPIO_PinConfig.GPIO_PinMode == GPIO_MODE_ALTFN)
	{
		//configure the alt function register
		uint8_t temp1,temp2;

		temp1 = pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber / 8;
		temp2 = pGPIOHandle->GPIO_PinConfig.GPIO_PinNumber % 8;
		pGPIOHandle->pGPIOx->AFR[temp1] &= ~(0xF << ( 4 * temp2 ) );
		pGPIOHandle->pGPIOx->AFR[temp1] |= (pGPIOHandle->GPIO_PinConfig.GPIO_PinAltFunMode << (4 * temp2) );
	}
}

/************************************************************
 * @fn			- GPIO_Init
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */

void GPIO_DeInit(GPIO_RegDef_t *pGPIOx)
{
	if(pGPIOx == GPIOA)
	{
		GPIOA_REG_RESET();
	}
	else if(pGPIOx == GPIOB)
	{
		GPIOB_REG_RESET();
	}
	else if(pGPIOx == GPIOC)
	{
		GPIOC_REG_RESET();
	}
	else if(pGPIOx == GPIOD)
	{
		GPIOD_REG_RESET();
	}
	else if(pGPIOx == GPIOE)
	{
		GPIOE_REG_RESET();
	}
	else if(pGPIOx == GPIOF)
	{
		GPIOF_REG_RESET();
	}
	else if(pGPIOx == GPIOG)
	{
		GPIOG_REG_RESET();
	}
	else if(pGPIOx == GPIOH)
	{
		GPIOH_REG_RESET();
	}
	else if(pGPIOx == GPIOI)
	{
		GPIOI_REG_RESET();
	}
}

/************************************************************
 * @fn			- GPIO_ReadFromInputPin
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */
uint8_t GPIO_ReadFromInputPin(GPIO_RegDef_t *pGPIOx,uint8_t PinNumber)
{
	uint8_t value;
	value = (uint8_t)((pGPIOx->IDR >> PinNumber ) & 0x00000001) ;
	return value;
}

/************************************************************
 * @fn			- GPIO_ReadFromInputPort
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */
uint16_t GPIO_ReadFromInputPort(GPIO_RegDef_t *pGPIOx)
{
	uint16_t value;
		value = (uint16_t)pGPIOx->IDR ;
		return value;
}

/************************************************************
 * @fn			- GPIO_WriteToOutputPin
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */

void GPIO_WriteToOutputPin(GPIO_RegDef_t *pGPIOx, uint8_t PinNumber, uint8_t value)
{
	if(value == GPIO_PIN_SET)
	{
		//write 1 to the output data register at the bit field corresponding to the pin number
		pGPIOx->ODR |= (1 << PinNumber);
	}
	else
	{
			//write 1 to the output data register at the bit field corresponding to the pin number
			pGPIOx->ODR &= ~(1 << PinNumber);
	}
}

/************************************************************
 * @fn			- GPIO_WriteToOutputPort
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */
void GPIO_WriteToOutputPort(GPIO_RegDef_t *pGPIOx, uint16_t value)
{
	pGPIOx->ODR = value;
}

/************************************************************
 * @fn			- GPIO_ToggleOutputPin
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */

void GPIO_ToggleOutputPin(GPIO_RegDef_t *pGPIOx, uint8_t PinNumber)
{
	pGPIOx->ODR  ^= ( 1 << PinNumber);
}

/************************************************************
 * @fn			- GPIO_IRQConfig
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */
void GPIO_IRQInterruptConfig(uint8_t IRQNumber, uint8_t EnorDi)
{
	if(EnorDi == ENABLE)
	{
		if(IRQNumber <= 31)
		{
			// program ISER0 register
			*NVIC_ISER0 |= (1 << IRQNumber );
		}
		else if(IRQNumber > 31 && IRQNumber < 64) //32 to 63
		{
			// program ISER1 register
			*NVIC_ISER1 |= (1 << IRQNumber % 32 );
		}
		else if(IRQNumber >= 64 && IRQNumber <96)//65 to 95
		{
			// program ISER2 register
			*NVIC_ISER2 |= (1 << IRQNumber % 64 );
		}
	}
	else
	{
		if(IRQNumber <= 31)
		{
			// program ISER0 register
			*NVIC_ICER0 |= (1 << IRQNumber );
		}
		else if(IRQNumber > 31 && IRQNumber < 64) //32 to 63
		{
			// program ISER1 register
			*NVIC_ICER1 |= (1 << IRQNumber % 32 );
		}
		else if(IRQNumber >= 64 && IRQNumber <96)//65 to 95
		{
			// program ISER2 register
			*NVIC_ICER2 |= (1 << IRQNumber % 64 );
		}
	}
}

/************************************************************
 * @fn			- GPIO_IRQPriorityConfig
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */

void GPIO_IRQPriorityConfig(uint8_t IRQNumber, uint32_t IRQPriority)
{
	//1. first lets find out the ipr register
	uint8_t iprx = IRQNumber / 4;
	uint8_t iprx_section = IRQNumber % 4 ;

	uint8_t shift_amount = ( 8 * iprx_section) + ( 8 - NO_PR_BITS_IMPLEMENTED);
	*(NVIC_PR_BASE_ADDR + iprx ) |= ( IRQPriority << shift_amount );
}

/************************************************************
 * @fn			- GPIO_IRQHandling
 *
 * @brief		- This function enables or disables peripheral clock for the given GPIO port
 *
 * @para[ in ]	- base address of the gpio peripheral
 * @para[ in ]	- ENABLE or DISABLE macros
 *  @para[ in ]	-
 *
 *  @return		- none
 *
 *  @note		- none
 *
 */
void GPIO_IRQHandling(uint8_t PinNumber)
{
	//clear the exti pr register corresponding to the pin number
	if(EXTI->PR & (1 << PinNumber))
	{
		//clear
		EXTI->PR |= (1 << PinNumber);
	}
}

